# Keil uVision project LoraNode.uvprojx, settings and files
target LoraNode-433-lora (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoraNode +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433 USE_MODEM_LORA xPING_PONG
  c include: ..\source;..\source\apps;..\source\boards\hardware;..\source\boards\hardware\cmsis;..\source\boards\mcu;..\source\boards\mcu\cmsis;..\source\boards\mcu\STM32L1xx_HAL_Driver\Inc;..\source\mac;..\source\peripherals;..\source\radio;..\source\system;..\source\system\crypto;..\source\peripherals\hal_oled;..\source\peripherals\hal_key;..\source\apps\business;..\source\apps\common;..\source\apps\utils;..\source\peripherals\hal_interupt;..\source\peripherals\hal_qrencode;..\source\peripherals\hal_TempRh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group apps
    ../source/apps/: main.c timer_handles.c lzyx_examples.h
  group apps\common
    ../source/apps/common/: adc_reader.c configs.c NS_Radio.c uart_receiver.c key_scaner.c led_light.c
  group apps\utils
    ../source/apps/utils/: misc.c
  group boards\hardware
    ../source/boards/hardware/: adc-board.c board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c tim-board.c uart-board.c usart1-board.c
  group boards\hardware\cmsis
    ../source/boards/hardware/cmsis/arm-std/: startup_stm32l151xb.s
    ../source/boards/hardware/cmsis/: system_stm32l1xx.c
  group boards\mcu\STM32L1xx_HAL_Driver
    ../source/boards/mcu/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group boards\mcu
    ../source/boards/mcu/: sysIrqHandlers.c utilities.c
  group peripherals
    ../source/peripherals/hal_key/: hal_key.c
    ../source/peripherals/hal_oled/: hal_oled.c
    ../source/peripherals/hal_interupt/: hal_it.c
    ../source/peripherals/hal_TempRh/: hal_temHum.c
  group radio
    ../source/radio/sx1276/: sx1276.c
  group system
    ../source/system/: adc.c delay.c fifo.c gpio.c timer.c uart.c flash.c iwdg.c
  group examples
    ../source/examples/: flash_ex.c led_alternate_blink_ex.c led_breath_ex.c led_btn_control_ex.c led_pwn.ex.c lora_led_ex.c lora_serial_transp_ex.c oled_date_ex.c oled_font_lib_ex.c relay_ex.c sensor_air_quality_ex.c sensor_body_ex.c sensor_fire_ex.c sensor_light_ex.c sensor_methane_ex.c sensor_tem_hum_ex.c timer_ex.c uart_ex.c
